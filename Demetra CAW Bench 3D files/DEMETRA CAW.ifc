Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:40:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:40:09 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{66A80B17-0F44-4519-8A63-60C1D52E9114}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:40:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:40:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:40:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA CAW:0PAAR165 - WITHOUT LEVELLING - VERDE ALPI:163405
In: 0 - Piano Terra
Type - Material: VERDE ALPI, CONIFERA
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA CAW
Type - Dati identità - BIM Name: DEMETRA CAW SENZA SISTEMA DI LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR165; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-c/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-c/
Type - Dimensioni - Dimensions: 1907 mm x 742 mm x 480 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca curva modulare mod. “DEMETRA” CAW costituita da una seduta monolitica con seduta completa integrata. Seduta in legno per fornire comfort sia in climi caldi che freddi."; Descrizione Tecnica per Codice: PANCA DEMETRA CAW SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON BORDI SUPERIORI BOCCIARDATI VERNICIATURA ANTI-DEGRADO E SEDUTA IN LEGNO DI CONIFERA; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Curved modular bench mod. “DEMETER” CAW consisting of a monolithic seat with seat fully integrated. Wooden seat to provide comfort in both hot and cold climates."; Technical Description for Article: DEMETRA CAW WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED UPPER RIMS ANTI-DECAY VARNISH AND CONIFER WOOD SEAT
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; Legno Conifera; MATERIALE SEDUTA: CONIFERA; MATERIALE SUPPORTO: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone; Coniferous wood
Type - Meccanica - Weight ( kg): 1074 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA CAW: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA CAW: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA CAW: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA CAW: 0PAAR165 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 4.40501 m2; Volume: 0.458129 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
